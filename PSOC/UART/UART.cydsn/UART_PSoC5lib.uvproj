# Keil uVision project UART_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: UART_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h UART.c UART.h UART_PM.c UART_INT.c isr_1.c isr_1.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD_Char_1.c LCD_Char_1.h LCD_Char_1_PM.c LCD_Char_1_LCDPort_aliases.h LCD_Char_1_LCDPort.c LCD_Char_1_LCDPort.h isr_2.c isr_2.h Pin_1_aliases.h ADC_DelSig.c ADC_DelSig.h ADC_DelSig_PM.c ADC_DelSig_INT.c ADC_DelSig_Ext_CP_Clk.c ADC_DelSig_Ext_CP_Clk.h ADC_DelSig_theACLK.c ADC_DelSig_theACLK.h ADC_DelSig_AMux.c ADC_DelSig_AMux.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: UART_PSoC5lib (library)
